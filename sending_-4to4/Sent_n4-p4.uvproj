# Keil uVision project Sent_n4-p4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Sent_n4-p4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Sending_port_n4_p4.c
